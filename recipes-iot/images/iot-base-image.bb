DESCRIPTION = "iot basic image."

inherit iot-base-image
