
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://motd \
           "
# Set HOSTNAME
hostname = "iot"

