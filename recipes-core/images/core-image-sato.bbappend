inherit iot-base-image
