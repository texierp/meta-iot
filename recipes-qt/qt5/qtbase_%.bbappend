
PACKAGECONFIG_append = " libinput linuxfb accessibility sql-sqlite"
PACKAGECONFIG_remove = " icu x11"
